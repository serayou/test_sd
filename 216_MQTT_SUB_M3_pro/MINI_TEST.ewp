# IAR project MINI_TEST.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: Source\; Source\Libraries\CMSIS\CM3\CoreSupport; Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Source\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash_0x08003000.bin
  ILINK.IlinkOutputFile: MINI_TEST.out
  ILINK.IlinkIcfFile: Flash_0x08003000.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Flash_0x08003000_Rel.bin
  group CMSIS
    Source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    Source/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group STM32F10x_StdPeriph_Driver/01.inc
    Source/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h
  group STM32F10x_StdPeriph_Driver/02.src
    Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER/01.inc
    Source/: device_driver.h macro.h option.h udf.h
    ../../03_RTOS/실습자료_배포용/001. FirmWare Examples/003_SPI_LCD_GRAPHICS_EX/Source/: st7735.h
  group USER/02.device
    Source/: ethernet.c socket.c timer.c uart.c w5500.c wizchip_conf.c
    ../../03_RTOS/실습자료_배포용/001. FirmWare Examples/003_SPI_LCD_GRAPHICS_EX/Source/: st7735.c
  group USER/03.app
    Source/: libemqtt.c main.c stm32f10x_it.c
